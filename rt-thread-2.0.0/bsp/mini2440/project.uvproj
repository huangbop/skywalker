# Keil uVision project project.uvproj, settings and files
target RT-Thread Mini2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: rtthread-mini2440
  c flags: Optim=1
  c misc: --diag_suppress=870
  c include: .;..\..\components\dfs;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\include;..\..\components\external\jpeg;..\..\components\external\libpng;..\..\components\external\libz;..\..\components\finsh;..\..\components\libdl;..\..\components\net\lwip\src;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\..\components\pthreads;..\..\components\rtgui\common;..\..\components\rtgui\include;..\..\components\rtgui\server;..\..\components\rtgui\widgets;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\s3c24x0
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: rtthread-mini2440.sct
  link misc: --keep __rtmsym_*   --keep __fsym_* --keep __vsym_*
  group Startup
    ./: application.c startup.c board.c console.c led.c sdcard.c dm9000.c lcd_t35.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group S3C24X0
    ../../libcpu/arm/s3c24x0/: cpu.c interrupt.c mmu.c rtc.c serial.c stack.c system_clock.c trap.c context_rvds.S start_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_fs.c dfs_file.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: cc936.c
    ../../components/dfs/filesystems/devfs/: devfs.c console.c
  group jpeg
    ../../components/external/jpeg/: jaricom.c jcomapi.c jutils.c jerror.c jmemmgr.c jdapimin.c jdapistd.c jdarith.c jdtrans.c jdmaster.c jdinput.c jdmarker.c jdhuff.c jdmainct.c jdcoefct.c jdpostct.c jddctmgr.c jidctfst.c jidctflt.c jidctint.c jdsample.c jdcolor.c jquant1.c jquant2.c jdmerge.c jmemnobs.c
  group libz
    ../../components/external/libz/: adler32.c compress.c crc32.c deflate.c infback.c inffast.c inflate.c inftrees.c trees.c uncompr.c zutil.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group libdl
    ../../components/libdl/: dlclose.c dlerror.c dlopen.c dlsym.c
  group LwIP
    ../../components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/src/arch/: sys_arch.c
    ../../components/net/lwip/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/netif/: etharp.c ethernetif.c slipif.c
  group pthreads
    ../../components/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
